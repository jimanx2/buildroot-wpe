## package/pythonnet/Config.in
```kconfig
config BR2_PACKAGE_PYTHONNET
	bool "pythonnet"
	help
	  .Net and Mono integration for Python

	  https://pypi.python.org/pypi/pythonnet
```
